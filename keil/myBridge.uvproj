# Keil uVision project myBridge.uvproj, settings and files
target MyBridge (ARM-ADS)
  device: STM32F103VF STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80BFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: myBridge +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_XL,USE_STM3210E_EVAL
  c include: ..\src\App\Interrupt;..\src\App;..\src\Driver\CMSIS;..\src\Driver\Lib\inc;..\src\Driver\Startup;..\src\App\System;..\src\App\Comm;..\src\Middleware\usb_lib\inc;..\src\Middleware\usb_user\inc;..\src\Middleware\freertos\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Driver/CMSIS
    ../src/Driver/CMSIS/: core_cm3.c system_stm32f10x.c
  group Driver/Startup
    ../src/Driver/Startup/: startup_stm32f10x_xl.s
  group Driver/Lib
    ../src/Driver/Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Middleware/freertos
    ../src/Middleware/freertos/src/: croutine.c event_groups.c list.c port.c queue.c stream_buffer.c tasks.c timers.c heap_4.c
  group Middleware/usb_lib
    ../src/Middleware/usb_lib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Middleware/usb_user
    ../src/Middleware/usb_user/src/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_port.c
  group App/Interrupt
    ../src/App/Interrupt/: stm32f10x_it.c
  group App/System
    ../src/App/System/: delay.c uart.c
  group App
    ../src/App/: main.c
